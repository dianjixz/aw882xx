## Kconfig
```kconfig
config AW882XX_DRV
       tristate "AW882XX_DRV sound support"
       default m
       help

		AW882XX_DRV sound support!
```
